<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtos_scratch\rtos_scratch.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\rtos_scratch\rtos_scratch\rtos_scratch.ewp</path>
    </project>
    <batchBuild />
</workspace>
